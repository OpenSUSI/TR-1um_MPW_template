v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {devices/title.sym} 0 0 0 0 {name=l1 author="jun1okamura"}
C {OSS_FRAME.sym} 120 -510 0 0 {name=x1}
C {devices/iopin.sym} 60 -580 0 1 {name=p1 lab=P1}
C {devices/iopin.sym} 60 -560 0 1 {name=p2 lab=P2}
C {devices/iopin.sym} 60 -540 0 1 {name=p3 lab=P3}
C {devices/iopin.sym} 60 -520 0 1 {name=p4 lab=P4
}
C {devices/iopin.sym} 60 -500 0 1 {name=p5 lab=P5}
C {devices/iopin.sym} 60 -480 0 1 {name=p6 lab=P6}
C {devices/iopin.sym} 60 -460 0 1 {name=p7 lab=P7}
C {devices/iopin.sym} 60 -440 0 1 {name=p8 lab=VSS}
C {devices/iopin.sym} 180 -580 0 0 {name=p9 lab=VDD}
C {devices/iopin.sym} 180 -560 0 0 {name=p10 lab=P15}
C {devices/iopin.sym} 180 -540 0 0 {name=p11 lab=P14}
C {devices/iopin.sym} 180 -520 0 0 {name=p12 lab=P13
}
C {devices/iopin.sym} 180 -500 0 0 {name=p13 lab=P12}
C {devices/iopin.sym} 180 -480 0 0 {name=p14 lab=P11}
C {devices/iopin.sym} 180 -460 0 0 {name=p15 lab=P10}
C {devices/iopin.sym} 180 -440 0 0 {name=p16 lab=P9}
